# Keil uVision project led-driver.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led-driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=2 v6LangP=2 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c N5510_INIT.s DELAY50.s NOT_READY.s PORTA_SSI0_INIT.S AnnounceResult.s FIFO_FULL.s SCREEN_MAP.s SET_XY.s char_write_to_array.s line_generator.s Nokia5110_fonts.h i2c.c i2c.h lux.c lux.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
